# Keil uVision project PID_car.uvproj, settings and files
target PID_car (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PID_car +hex
  c flags: Optimize=8 SizeSpeed=1
  group USERS
    ./USERS/: car.c delay.c main.c SR04.c lcd_tft.c word_modle.c pid.c uart.c
