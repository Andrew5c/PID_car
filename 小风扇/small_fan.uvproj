# Keil uVision project small_fan.uvproj, settings and files
target small_fan (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: small_fan +hex
  c flags: Optimize=8 SizeSpeed=1
  group users
    ./users/: main.c motor.c uart.c
