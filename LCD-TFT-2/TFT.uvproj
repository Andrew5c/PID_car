# Keil uVision project TFT.uvproj, settings and files
target LCD-TFT-2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TFT +hex
  c flags: Optimize=8 SizeSpeed=1
  group USERS
    ./USERS/: main.c tft.c word_modle.c ds1302.c key.c temp.c
